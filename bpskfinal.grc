options:
  parameters:
    description: BPSK
    generate_options: qt_gui
    id: BPSK
    output_language: python
    title: BPSK (PlutoSDR)
  states: {}

blocks:
- name: audio_sample_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Voltage
    start: '0'
    step: '0.001'
    stop: '0.5'
    value: '0.0'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: symbols_per_sample
  id: variable
  parameters:
    value: '4'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1.0'
    type: float
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: symbols_per_sample
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/0.5
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: symbols_per_sample
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\HP\Desktop\wav file\suprabatham.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[-1+0j, 1+0j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.05'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '200000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '915000000'
    samplerate: sample_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: '915000000'
    gain1: '''slow_attack'''
    len_tag_key: groestl_pluto
    manual_gain1: '40'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,2,1
    label1: Symbols
    name: '"BPSK Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,1,1,1
    label1: TX Baseband
    name: '"TX Baseband Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: Recovered Audio
    name: '"Recovered Audio"'
    size: '1024'
    srate: audio_sample_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '101'
    samp_rate: '192000'
    sym_rate: '48000'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '101'
    samp_rate: '192000'
    sym_rate: '48000'
    type: fir_filter_ccf
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_uchar_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_repeat_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_repeat_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_wavfile_source_0, '0', blocks_add_const_vxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [iio_pluto_source_0, '0', root_raised_cosine_filter_1, '0']
- [root_raised_cosine_filter_0, '0', iio_pluto_sink_0, '0']
- [root_raised_cosine_filter_1, '0', digital_costas_loop_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
